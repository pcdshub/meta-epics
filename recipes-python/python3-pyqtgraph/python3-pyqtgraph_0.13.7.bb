# python3-pyqtgraph_0.14.0.bb
inherit pypi python_setuptools_build_meta

SUMMARY = "The pyqtgraph module from PyPi"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=f3e5f0e3bfada0ee09266e5402b0a690"

BBCLASSEXTEND = "native nativesdk"
PYPI_PACKAGE = "pyqtgraph"

SRC_URI[sha256sum] = "64f84f1935c6996d0e09b1ee66fe478a7771e3ca6f3aaa05f00f6e068321d9e3"