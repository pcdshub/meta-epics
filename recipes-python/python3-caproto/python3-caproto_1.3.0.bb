SUMMARY = "a sans-I/O implementation of the EPICS Channel Access protocol"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=8041fbcd13958873d5adeadbd0295ace"

SRC_URI[sha256sum] = "ea74f433297e895695c80a706a2389f745a94d756b5835c80af73af3df585cba"

inherit pypi setuptools3

PYPI_PACKAGE = "caproto"
