require epics-devgpiogeneric.inc

SRCREV = "4ed586f28cd7ea1b06db503882b09cc03cf2c2ed"
